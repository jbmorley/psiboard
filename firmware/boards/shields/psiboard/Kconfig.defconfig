## firmware/boards/shields/psiboard/Kconfig.defconfig
```kconfig
if PSIBOARD

config BT
    default y

config ZMK_BLE
	default y

config ZMK_KEYBOARD_NAME
    default "PsiBoard"

endif
```
